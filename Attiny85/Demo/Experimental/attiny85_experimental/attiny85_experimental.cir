* /home/ash98/eSim-Workspace/attiny85_experimental/attiny85_experimental.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Fri May  1 12:43:09 2020

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U5  Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ PB0 GND GND GND dac_bridge_4
U4  Ref2 plot_v1
U6  Ref3 plot_v1
U3  Ref1 plot_v1
X1  ? Net-_R5-Pad1_ Net-_R6-Pad1_ Net-_X1-Pad4_ ? Out1 Net-_X1-Pad7_ ? lm_741
R5  Net-_R5-Pad1_ Ref1 1k
X2  ? Net-_R9-Pad1_ Net-_R10-Pad1_ Net-_X1-Pad4_ ? Out2 Net-_X1-Pad7_ ? lm_741
R9  Net-_R9-Pad1_ Ref2 1k
R7  Net-_R7-Pad1_ Ref3 1k
R6  Net-_R6-Pad1_ V_In 1k
R10  Net-_R10-Pad1_ V_In 1k
R8  Net-_R8-Pad1_ V_In 1k
R11  Net-_R11-Pad1_ Out1 1k
R12  Net-_R12-Pad1_ Out2 1k
R13  Net-_R13-Pad1_ Out3 1k
v3  Net-_X1-Pad7_ GND 12
U8  Out1 plot_v1
U9  Out2 plot_v1
U10  Out3 plot_v1
v4  GND Net-_X1-Pad4_ 12
U11  Net-_R11-Pad1_ Net-_R12-Pad1_ Net-_R13-Pad1_ Net-_U11-Pad4_ Net-_U11-Pad5_ Net-_U11-Pad6_ adc_bridge_3
U14  Net-_U1-Pad4_ Net-_U1-Pad5_ Bin1 Bin2 dac_bridge_2
U2  V_In plot_v1
v1  Net-_R1-Pad2_ GND 4
R1  Ref1 Net-_R1-Pad2_ 1k
R2  Ref2 Ref1 1k
R3  Ref3 Ref2 1k
R4  GND Ref3 1k
U7  Net-_U11-Pad4_ Net-_U11-Pad5_ Net-_U11-Pad6_ Net-_U1-Pad4_ Net-_U1-Pad5_ therm2bin2bit
v2  V_In GND pwl
X3  ? Net-_R7-Pad1_ Net-_R8-Pad1_ Net-_X1-Pad4_ ? Out3 Net-_X1-Pad7_ ? lm_741
R14  GND Bin1 1k
U15  Bin1 plot_v1
R15  GND Bin2 1k
U13  Bin2 plot_v1
R16  GND Net-_D1-Pad2_ 1k
U12  Net-_U12-Pad1_ GND Net-_U12-Pad3_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ adc_bridge_3
v6  Net-_U12-Pad1_ GND DC
v5  Net-_U12-Pad3_ GND pulse
U16  PB0 plot_v1
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ attiny85_exp
D1  PB0 Net-_D1-Pad2_ eSim_LED

.end
